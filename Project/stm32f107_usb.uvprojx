# Keil uVision project stm32f107_usb.uvprojx, settings and files
target stm32f107_usb (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f107_usb +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ..\Core;..\Driver\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\CMSIS_RTOS;..\Library\myLib;..\User;..\Middle\STM32_USB_Host_Library\Core\Inc;..\Middle\STM32_USB_Host_Library\Class\MSC\Inc;..\Middle\STM32_USB_Host_Library\Class\CH340\Inc;..\Middle\STM32_USB_Host_Library\Class\HUB\Inc;..\Middle\FatFs\src;..\Middle\FatFs\src\drivers;..\Middle\LwIP\system;..\Middle\LwIP\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/: cmsis_armcc.h core_cm3.h startup_stm32f107xc.s
  group Driver
    ../Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_dma.c stm32f1xx_ll_gpio.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c stm32f1xx_ll_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_pwr.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group FreeRTOS/portable
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Library
    ../Library/myLib/: systemclockset.c systemDelay.c systemlog.c systemUartInit.c
  group User
    ../User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c test_lwip.c test_usbh.c test_lwip_seq_api.c test_lwip_tcp_udp_echo_server.c
  group Middle/USBH/Core
    ../Middle/STM32_USB_Host_Library/Core/Src/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middle/USBH/Class/MSC
    ../Middle/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middle/USBH/Class/FAT
    ../Middle/FatFs/src/option/: syscall.c
    ../Middle/FatFs/src/drivers/: usbh_diskio_dma.c
    ../Middle/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middle/USBH/Class/CH340
    ../Middle/STM32_USB_Host_Library/Class/CH340/Src/: usbh_ch340.c
  group Middle/USBH/Class/HUB
    ../Middle/STM32_USB_Host_Library/Class/HUB/Src/: usbh_hub.c
  group Middle/LWIP
    ../Middle/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middle/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middle/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middle/LwIP/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../Middle/LwIP/system/OS/: sys_arch.c
